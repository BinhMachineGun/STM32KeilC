# Keil uVision project Prac1.uvprojx, settings and files
target Prac1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Prac1 +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\System\BoardSupport;..\System\Libraries\CMSIS\CM3\CoreSupport;..\System\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\System\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Users;..\System\FreeRTOS\include;..\System\FreeRTOS\portable\MemMang;..\System\FreeRTOS\portable\RVDS\ARM_CM3;.\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS
    ../System/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../System/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../System/FreeRTOS/portable/MemMang/: heap_2.c
  group BoardSupport
    ../System/BoardSupport/: AMES_LED.c AMES_BUTTON.c AMES_PWM.c AMES_ACS712.c AMES_USART.c
    ./BoardSupport/: AMES_RCC72MHZ.c
  group Libraries
    ../System/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ../System/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c
  group Users
    ./Users/: main.c
